<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>four_level_symbol_mapper</value></param>
<param><key>author</key><value>Colter McQuay</value></param>
<param><key>category</key><value>Colter</value></param>
<param><key>description</key><value>Maps symbols in the set of [1,3,-1,3] to [0,1,2,3]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>Symbol Mapper</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>bytes</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>symbols</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>symbol_map</value></param>
<param><key>label</key><value>Symbol Map</value></param>
<param><key>value</key><value>[1,3,-1,-3]</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>symbol_mapper</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each this file is saved, GRC will instantiate the first class it finds to get
ports and parameters of your block. The arguments to __init__  will be the
parameters. All of them are required to have default values!
"""
import numpy as np
from gnuradio import gr


class SymbolMapper(gr.sync_block):
    def __init__(self, codeMap=[]):  # only default arguments here
        gr.sync_block.__init__(
            self,
            name='Symbol Mapper',
            in_sig=[np.float32],
            out_sig=[np.byte]
        )
        self.codeMap = np.asarray(codeMap)

    def find_nearest(self,value):
	idx = (np.abs(self.codeMap - value)).argmin()
	return idx

    def work(self, input_items, output_items):
	if(len(input_items)==0):
		return 0
	else:	
	        output_items[0][:] = [np.ushort(self.find_nearest(x)) for x in input_items[0]]
        	return len(input_items[0])
</value></param>
<param><key>codeMap</key><value>symbol_map</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>symbol_mapper</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>symbol_mapper</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
